Commit message: working URDF model

File: robot_model/urdf/model.urdf (robot description, URDF)
Before this commit: robot a_mobile_manipulator, 5 links, 4 joints
Joints:
- joint left_wheel_hinge: type continuous -> revolute
- joint right_wheel_hinge: type continuous -> revolute
